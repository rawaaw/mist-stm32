# Keil uVision project mist.uvprojx, settings and files
target mist_stm32_dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mist_stm32
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MIST_STM32,USE_HAL_DRIVER,STM32F407xx,MIST_STM32_DBG=0
  c include: .\inc;.\inc\usb;.\inc\wpjrunner;.\inc\ps2;.\RTE\Device\STM32F407VETx\STCubeGenerated\Inc;.\RTE\Device\STM32F407VETx\STCubeGenerated/Drivers/STM32F4xx_HAL_Driver/Inc;.\RTE\Device\STM32F407VETx\STCubeGenerated/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;.\RTE\Device\STM32F407VETx\STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;.\RTE\Device\STM32F407VETx\STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;.\RTE\Device\STM32F407VETx\STCubeGenerated/Drivers/CMSIS/Include;.\RTE\Device\STM32F407VETx\STCubeGenerated/Drivers/CMSIS/Device/ST/STM32F4xx/Include;.\inc\printf
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group wpjrunner_src
    ./src/wpjrunner/: jb_io_stm32.c jb_jtag_stm32.c jrunner_stm32.c
  group wpjrunner_inc
    ./inc/wpjrunner/: jb_const.h jb_device.h jb_io.h jb_jtag.h
  group ps2_src
    ./src/ps2/: ps2_kbd.c
  group ps2_inc
    ./inc/ps2/: ps2.h
  group printf_src
    ./src/printf/: printf.c
  group printf_inc
    ./inc/printf/: printf.h
  group src
    ./src/: archie.c boot.c cdc_control.c cdc_enumerate.c config.c Cstartup_SAM7.c fat.c fdd.c firmware.c fpga.c hardware.c hdd.c idxfile.c ikbd.c ini_parser.c main.c menu.c mist_cfg.c mmc.c osd.c rafile.c Retarget.c spi.c stm32_stubs.c swap.c tos.c user_io.c xmodem.c
    ./src/usb/: asix.c hid.c hidparser.c hub.c joymapping.c max3421e.c pl2303.c storage.c timer.c usb.c usbrtc.c
  group inc
    ./inc/: archie.h AT91SAM7S256.h boot.h cdc_control.h cdc_enumerate.h charrom.h config.h debug.h errors.h fat.h fdd.h firmware.h fpga.h hardware.h hdd.h hdd_internal.h idxfile.h ikbd.h ini_parser.h keycodes.h logo.h menu.h mist_cfg.h mmc.h osd.h rafile.h spi.h swap.h swi.h tos.h user_io.h xmodem.h
    ./inc/usb/: asix.h asix_const.h hid.h hidparser.h hub.h joymapping.h max3421e.h mii.h pl2303.h storage.h timer.h usb.h usbrtc.h
  group STM32CubeMX_startup
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
    ./RTE/Device/STM32F407VETx/: startup_stm32f407xx.s
  group Drivers/CMSIS
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c
  group Middlewares/USB_Device_Library
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
